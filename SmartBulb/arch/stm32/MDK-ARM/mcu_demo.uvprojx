# Keil uVision project mcu_demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mcu_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\lib\STM32F10x_FWLib\inc;..\device;..\main;..\core;..\system\delay;..\system\usart;..\..\..\user\app;..\..\..\user\handler;..\..\..\user\ota;..\..\..\user\ota\xmodem;..\..\..\miio\util;..\..\..\miio\uart;..\..\..\miio\device\codec;..\..\..\miio\device\typedef;..\..\..\miio;..\..\..\miio\device;..\..\..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group lib
    ../lib/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group main
    ../main/: main.c stm32f10x_it.c system_stm32f10x.c
  group system
    ../system/delay/: delay.c
    ../system/usart/: usart.c
  group device
    ../device/: arch_dbg.c arch_init.c arch_os.c arch_ota.c arch_uart.c
  group user
    ../../../user/ota/: ota.c
    ../../../user/ota/xmodem/: crc16.c xmodem.c
    ../../../user/handler/: on_action_invoke.c on_property_get.c on_property_set.c print_value.c S_1_DeviceInformation_doGet.c S_2_Switch_doChange.c S_2_Switch_doGet.c S_2_Switch_doSet.c S_3_IndicatorLight_doChange.c S_3_IndicatorLight_doGet.c S_3_IndicatorLight_doSet.c S_4_Customer_doAction.c S_4_Customer_doChange.c S_4_Customer_doEvent.c S_4_Customer_doGet.c S_4_Customer_doSet.c S_5_Vacuum_doAction.c S_5_Vacuum_doChange.c S_5_Vacuum_doGet.c S_5_Vacuum_doSet.c
    ../../../user/app/: user_app_func.c user_app_main.c
  group miio_api
    ../../../miio/: miio_api.c
    ../../../miio/device/: operation_executor.c
    ../../../miio/uart/: miio_uart.c
    ../../../miio/util/: util.c
    ../../../miio/device/codec/: action_operation_decoder.c action_operation_encoder.c event_operation_encoder.c property_changed_encoder.c property_operation_decoder.c property_operation_encoder.c uart_command_decoder.c
    ../../../miio/device/typedef/: action_operation.c argument.c arguments.c event_operation.c property_operation.c property_value.c
